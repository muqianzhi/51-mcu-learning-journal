# Keil uVision project 13-2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 13-2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h Delay.c Delay.h DS18B20.c DS18B20.h I2C.c I2C.h LCD1602.c LCD1602.h OneWire.c OneWire.h Key.c Key.h Timer0.c Timer0.h
